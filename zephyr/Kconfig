## zephyr/Kconfig
```kconfig
menu "app_util_lib options"

config APP_UTIL_LIB
    bool "Enable app_util_lib Library"
    default y
    help
      Enable support for app_util_lib.


endmenu
```
